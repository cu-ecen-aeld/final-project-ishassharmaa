## base_external/package/aesd-project/Config.in
```kconfig
config BR2_PACKAGE_AESD_PROJECT
	bool "aesd-project"
	help
	  Includes the application for LCD.
```
